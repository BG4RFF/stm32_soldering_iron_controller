# Keil uVision project iron.uvprojx, settings and files
target iron (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iron
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Inc;..\Src;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\generalIO;..\Drivers\graphics;..\Drivers\graphics\gui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c iron.c settings.c pid.c
  group Drivers/graphics
    ../Drivers/graphics/: ssd1306.c ugui.c
  group Drivers/graphics/gui
    ../Drivers/graphics/gui/: gui.c oled.c calibration_screen.c debug_screen.c main_screen.c screen.c settings_screen.c splash.c widgets.c
  group Drivers/generalIO
    ../Drivers/generalIO/: voltagesensors.c tempsensors.c rotary_encoder.c buzzer.c adc_global.c
  group Drivers/CMSIS
    ./: startup_stm32f103xb.s
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
